Commit message: map load is working

File: install/my_robot_description/share/my_robot_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot mechatronics_robot, 5 links, 4 joints
Joints:
- joint livox_joint: origin xyz=0.1 0 0.15 rpy=0 0 0 -> xyz=0.1 0 0.20 rpy=0 0 0
